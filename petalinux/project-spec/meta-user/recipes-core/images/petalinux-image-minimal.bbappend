IMAGE_INSTALL:append = " \
    yeet-data-tdc \
    yeet-data-ct \
    threshold \
    fpga-bitstreams \
    fpga-load \
    devmem2 \
"
